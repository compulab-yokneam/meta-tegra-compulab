EDGE_AI_DEB_COMPONENT = "gstreamer"
require edge-ai-deb.inc
