EDGE_AI_DEB_COMPONENT = "camera-support"
require edge-ai-deb.inc
