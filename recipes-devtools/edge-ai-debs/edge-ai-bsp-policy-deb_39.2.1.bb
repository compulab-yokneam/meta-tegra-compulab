EDGE_AI_DEB_COMPONENT = "bsp-policy"
require edge-ai-deb.inc
