EDGE_AI_DEB_COMPONENT = "boot-tools"
require edge-ai-deb.inc
