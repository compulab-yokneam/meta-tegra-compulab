FILESEXTRAPATHS:prepend:edgeai-orn := "${THISDIR}/files:"

SRC_URI:append:edgeai-orn = " file://compulab.cfg"
