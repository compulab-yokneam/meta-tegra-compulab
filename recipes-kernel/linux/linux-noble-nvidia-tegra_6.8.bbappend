# Carrier driver ports for the optional NVIDIA Noble 6.8 kernel.
# The default Linux 6.18 kernel keeps its independent patch queue.
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:edge-ai = " \
    file://edge-ai-peripherals/0001-media-Port-RK628-CSI-bridge-to-Noble-6.8.patch \
    file://edge-ai-peripherals/0002-serial-Port-dedicated-Tegra-RS485-driver-to-6.8.patch \
    file://edge-ai-peripherals/0003-watchdog-Add-separate-enable-and-ping-GPIO-watchdog.patch \
    file://edge-ai-peripherals/0004-media-Select-ADV7280-for-the-Edge-AI-PAL-adapter.patch \
    file://edge-ai-peripherals/peripherals.cfg \
"

# do_shared_workdir clears the staged output tree. make-mod-scripts may keep
# its previous configure stamp during an incremental/multiconfig rebuild,
# while NVIDIA's module clean/build commands enter this directory directly.
# Always recreate the same forwarding Makefile generated by kernel prepare.
do_shared_workdir:append:edge-ai() {
    printf 'include %s/Makefile\n' '${STAGING_KERNEL_DIR}' \
        > ${STAGING_KERNEL_BUILDDIR}/Makefile
}
