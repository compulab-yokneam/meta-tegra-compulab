FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-platform-preboot-allow-explicit-root-selection.patch"
