# Both families use the Nano NVMe partition layout and Super platform alias.
HOSTAPP_HOOKS:append:edgeai-orn = " 99-resin-bootfiles-orin-nano-devkit-nvme"
