# FIXME: Replace this generic developer-kit blob with a validated Edge-AI QSPI
# image generated using the CompuLab pinmux and flash variables.
BOOTBLOB:edge-ai-nx = "boot0_orin_nano_devkit_nvme_super.img.gz"
PARTSPEC:edge-ai-nx = "partition_specification234_orin_nano.txt"
BOOTBLOB:edge-ai-nano = "boot0_orin_nano_devkit_nvme_super.img.gz"
PARTSPEC:edge-ai-nano = "partition_specification234_orin_nano.txt"
