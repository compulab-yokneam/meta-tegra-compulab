# SPDX-License-Identifier: MIT
# Copyright (c) 2026 CompuLab Ltd.
EDGE_AI_SDK_FIRMWARE_ROLE = "rcm"
require recipes-bsp/uefi/edge-ai-sdk-firmware-export.inc
